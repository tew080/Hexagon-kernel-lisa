## drivers/cpufreq_bouncing/Kconfig
```kconfig
config OPLUS_FEATURE_CPUFREQ_BOUNCING
	tristate "cpufreq_bouncing"
	default y
	help
	  adjust cpu max frequency based on cpu busy duration
```
